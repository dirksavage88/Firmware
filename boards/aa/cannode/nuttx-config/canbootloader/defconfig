## src/drivers/distance_sensor/vl53l5cx/Kconfig
```kconfig
menuconfig DRIVERS_DISTANCE_SENSOR_VL53L5CX
	bool "vl53l5cx"
	default n
	---help---
		Enable support for vl53l5cx
```
